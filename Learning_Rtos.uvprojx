# Keil uVision project Learning_Rtos.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Learning_Rtos
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./Source/: main.c switch.c myRtos.h tBitmap.c tLib.h tConfig.h tList.c tTask.c tTime.c tCpu.c app.c tEvent.c tEvent.h tTask.h tSem.h tSem.c tMbox.c tMbox.h tMemBlock.h tMemBlock.c tFlagGroup.h tFlagGroup.c tMutex.c tMutex.h tTimer.h tTimer.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
